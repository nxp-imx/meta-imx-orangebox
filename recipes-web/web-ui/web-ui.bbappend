do_compile:prepend(){
cp -r ${UNPACKDIR}/* ${WORKDIR}/
}
